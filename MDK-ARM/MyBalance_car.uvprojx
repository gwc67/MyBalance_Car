# Keil uVision project MyBalance_car.uvprojx, settings and files
target MyBalance_car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: SPI_HAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER,USE_HAL_DRIVER
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Core;../Core/Src/OLED;../Core/Src/Key
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: system_stm32f1xx.c main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Core/: ALL.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_tim.c stm32f1xx_ll_gpio.c stm32f1xx_ll_dma.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group OLED
    ../Core/Src/OLED/: OLED_Data.c OLED.h OLED.c OLED_Data.h
  group Key
    ../Core/Src/Key/: Key.h Key.c
software components: CMSIS:CORE 4.3.0
